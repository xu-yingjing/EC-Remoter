# Keil uVision project EC-Remoter.uvprojx, settings and files
target EC-Remoter (6210000::V6.21::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.2
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: EC-Remoter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AIR001_DEV,USE_HAL_DRIVER
  c include: ..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\AIR001xx\Include;..\Drivers\AIR001xx_HAL_Driver\Inc;..\Drivers\AIR001xx_HAL_Driver\Inc\Legacy;..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_air001_dev.s
  group Application/User/Core
    ../Core/Src/: main.c air001xx_it.c air001xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_rcc.c air001xx_hal_flash.c air001xx_hal_gpio.c
  group Drivers/CMSIS
    ../Core/Src/: system_air001xx.c
software components: CMSIS:CORE 6.0.0
